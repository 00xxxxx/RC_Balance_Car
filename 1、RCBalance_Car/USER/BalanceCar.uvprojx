# Keil uVision project BalanceCar.uvprojx, settings and files
target BaclanceCar (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalanceCar +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\MPU6050\eMPL;..\HARDWARE;..\HARDWARE\usart2;..\HARDWARE\timer;..\HARDWARE\pwm;..\HARDWARE\oled;..\HARDWARE\mpu6050;..\HARDWARE\mpu_exti;..\HARDWARE\motor;..\HARDWARE\led;..\HARDWARE\encoder;..\HARDWARE\datascope_DP;..\HARDWARE\control;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\SysTick;D:\Keil_v5\Packs\ARM\CMSIS\5.9.0\CMSIS\Core\Include;..\APPLICATION
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/SysTick/: SysTick.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FreeRTOS_Cor
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Por
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group MPU6050
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group HARDWARE
    ../HARDWARE/datascope_DP/: DataScope_DP.C
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/mpu_exti/: mpu_exti.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/pwm/: pwm.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/usart2/: usart2.c
  group Application_PID
    ../APPLICATION/: Application_PID.c TaskManage.c
  group README
    ../: README.TXT
