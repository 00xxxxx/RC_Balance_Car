# Keil uVision project BalanceCar.uvprojx, settings and files
target BaclanceCar (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalanceCar +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\MPU6050\eMPL;..\HARDWARE;..\HARDWARE\usart2;..\HARDWARE\timer;..\HARDWARE\pwm;..\HARDWARE\oled;..\HARDWARE\mpu6050;..\HARDWARE\mpu_exti;..\HARDWARE\motor;..\HARDWARE\led;..\HARDWARE\encoder;..\HARDWARE\datascope_DP;..\HARDWARE\control
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group README
    ../: README.TXT
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group MPU6050
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group mpu_exti
    ../HARDWARE/mpu_exti/: mpu_exti.c
  group control
    ../HARDWARE/control/: control.c
  group encoder
    ../HARDWARE/encoder/: encoder.c
  group motor
    ../HARDWARE/motor/: motor.c
  group pwm
    ../HARDWARE/pwm/: pwm.c
  group timer
    ../HARDWARE/timer/: timer.c
  group usart2
    ../HARDWARE/usart2/: usart2.c
  group oled
    ../HARDWARE/oled/: oled.c
  group led
    ../HARDWARE/led/: led.c
  group datascope_DP
    ../HARDWARE/datascope_DP/: DataScope_DP.C
